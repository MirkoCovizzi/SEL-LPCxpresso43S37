# IAR project lib_lpc_board_nxp_lpcxpresso_4337_m0.ewp, settings and files
configuration nxp_lpcxpresso_4337_m0 (ARM)
  General.OGChipSelectEditMenu: LPC4337_M0 NXP LPC4337_M0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: NDEBUG; CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../lpc_chip/chip_18xx_43xx; ../../../lpc_chip/chip_18xx_43xx/config_43xx; ../../../lpc_chip/chip_18xx_43xx/config_43xx_m0app; ../../../lpc_chip/chip_common; ../../../../CMSIS/CMSIS/Include; ../../board_common; $PROJ_DIR$
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  ILINK.IlinkOutputFile: lib_lpc_board_nxp_lpcxpresso_4337_m0.out
  group src
    ./: board.c board_sysinit.c
    ../../board_common/: lcd_st7565s.c lpc_phy_smsc87x0.c
