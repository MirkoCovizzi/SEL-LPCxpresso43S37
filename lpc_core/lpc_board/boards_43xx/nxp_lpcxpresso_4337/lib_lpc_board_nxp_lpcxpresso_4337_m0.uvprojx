# Keil uVision project lib_lpc_board_nxp_lpcxpresso_4337_m0.uvprojx, settings and files
target nxp_lpcxpresso_4337_m0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4337:Cortex-M0 NXP
  pack: Keil.LPC4300_DFP.2.8.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: lib_lpc_board_nxp_lpcxpresso_4337_m0 (library)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\CMSIS\CMSIS\Include;..\..\..\lpc_chip\chip_18xx_43xx;..\..\..\lpc_chip\chip_18xx_43xx\config_43xx_m0app;..\..\..\lpc_chip\chip_common;..\..\board_common;.
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ./: board.c board_sysinit.c
    ../../board_common/: wm8904.c lcd_st7565s.c lpc_phy_smsc87x0.c
