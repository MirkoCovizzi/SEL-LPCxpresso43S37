# IAR project hid_generic.ewp, settings and files
configuration iflash_nxp_lpcxpresso_4337 (ARM)
  General.OGChipSelectEditMenu: LPC4337_M4 NXP LPC4337_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/config_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_common; ../../../../../../software/CMSIS/CMSIS/Include; ../../../../../../software/lpc_core/lpc_board/board_common; ..\..\..\..\..\..\software\lpc_core\lpc_chip\usbd_rom; ..\..\..\..\examples\usbd_rom\hid_generic
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  OBJCOPY.OOCOutputFile: blinky.srec
  ILINK.IlinkOutputFile: hid_generic.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../../examples/usbd_rom/hid_generic/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/iar_output/nxp_lpcxpresso_4337/Exe/: lib_lpc_board_nxp_lpcxpresso_4337.a
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/iar_output/chip_43xx_lib/Exe/: lib_lpc_chip_43xx.a
  group src
    ../../../../examples/usbd_rom/hid_generic/: hid_desc.c hid_generic.c hid_main.c
    ../../../../startup_code/: iar_startup_lpc18xx43xx.s sysinit.c
