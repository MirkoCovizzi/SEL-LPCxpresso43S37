# IAR project pmc_states.ewp, settings and files
configuration iflash_nxp_lpcxpresso_4337 (ARM)
  General.OGChipSelectEditMenu: LPC4337_M4 NXP LPC4337_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/config_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_common; ../../../../../../software/CMSIS/CMSIS/Include; ../../../../../../software/lpc_core/lpc_board/board_common
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  OBJCOPY.OOCOutputFile: pmc_states.srec
  ILINK.IlinkOutputFile: pmc_states.out
  ILINK.IlinkIcfFile: ../../../../../../applications/lpc18xx_43xx/tool_configs/iar_linker_scripts/lpc18xx_43xx_pmc_iflash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../../examples/misc/pmc_states/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/iar_output/nxp_lpcxpresso_4337/Exe/: lib_lpc_board_nxp_lpcxpresso_4337.a
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/iar_output/chip_43xx_lib/Exe/: lib_lpc_chip_43xx.a
  group src
    ../../../../startup_code/: iar_startup_lpc18xx43xx.s sysinit.c
    ../../../../examples/misc/pmc_states/: pmc_states.c
