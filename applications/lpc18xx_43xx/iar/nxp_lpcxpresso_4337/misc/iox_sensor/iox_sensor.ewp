# IAR project iox_sensor.ewp, settings and files
configuration iflash_nxp_lpcxpresso_4337 (ARM)
  General.OGChipSelectEditMenu: LPC4337_M4 NXP LPC4337_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/config_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_common; ../../../../../../software/CMSIS/CMSIS/Include; ../../../../../../software/lpc_core/lpc_board/board_common; ..\..\..\..\..\..\software\swim
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  OBJCOPY.OOCOutputFile: adc.srec
  ILINK.IlinkOutputFile: iox_sensor.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../../examples/misc/iox_sensor/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/iar_output/nxp_lpcxpresso_4337/Exe/: lib_lpc_board_nxp_lpcxpresso_4337.a
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/iar_output/chip_43xx_lib/Exe/: lib_lpc_chip_43xx.a
  group src
    ../../../../startup_code/: iar_startup_lpc18xx43xx.s sysinit.c
    ../../../../examples/misc/iox_sensor/: iox_sensor.c
    ../../../../../../software/swim/: lpc_rom8x8.c
