# IAR project sa_blinky_m0app.ewp, settings and files
configuration spifi_nxp_lpcxpresso_4337 (ARM)
  General.OGChipSelectEditMenu: LPC4337_M0 NXP LPC4337_M0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: CORE_M0
  ICCARM.CCDiagSuppress: Pa050,Pa082
  ICCARM.CCIncludePath2: ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/config_43xx_m0app; ../../../../../../software/lpc_core/lpc_chip/chip_common; ../../../../../../software/CMSIS/CMSIS/Include; ../../../../../../software/lpc_core/lpc_board/board_common; ..\..\..\..\examples\multicore\common; ..\..\..\..\examples\multicore\sa_blinky_m0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  OBJCOPY.OOCOutputFile: timers.srec
  ILINK.IlinkOutputFile: sa_blinky_m0app.out
  ILINK.IlinkIcfFile: ..\..\..\..\tool_configs\iar_linker_scripts\lpc43xx_m0app_ldscript_iflash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../../examples/multicore/sa_blinky_m0/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/iar_output/nxp_lpcxpresso_4337_m0/Exe/: lib_lpc_board_nxp_lpcxpresso_4337_m0.a
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/iar_output/chip_43xx_m0_lib/Exe/: lib_lpc_chip_43xx_m0.a
  group src
    ../../../../examples/multicore/sa_blinky_m0/: blinky_m0.c
    ../../../../startup_code/: iar_startup_lpc43xx_m0app.s sysinit.c
    ../../../../examples/multicore/common/: ipc_example.c ipc_msg.c
