# IAR project usbhost_msc.ewp, settings and files
configuration iflash_nxp_lpcxpresso_4337 (ARM)
  General.OGChipSelectEditMenu: LPC4337_M4 NXP LPC4337_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CORE_M4; __LPC43XX__; USB_HOST_ONLY
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/config_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_common; ../../../../../../software/CMSIS/CMSIS/Include; ../../../../../LPCUSBlib/lpcusblib_MassStorageHost; ../../../../../../software/lpc_core/lpc_board/board_common; ../../../../../../software/LPCUSBLib/Drivers/USB; ../../../../../../software/filesystems/fatfs/src; ../../../../../../software/filesystems/fatfslpc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  OBJCOPY.OOCOutputFile: blinky.srec
  ILINK.IlinkOutputFile: usbhost_msc.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/iar_output/nxp_lpcxpresso_4337/Exe/: lib_lpc_board_nxp_lpcxpresso_4337.a
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/iar_output/chip_43xx_lib/Exe/: lib_lpc_chip_43xx.a
  group src
    ../../../../startup_code/: iar_startup_lpc18xx43xx.s sysinit.c
    ../../../../../LPCUSBlib/lpcusblib_MassStorageHost/: MassStorageHost.c
  group src/fatfs
    ../../../../../../software/filesystems/fatfs/src/: ff.c
    ../../../../../../software/filesystems/fatfslpc/: fs_usb.c rtc.c
  group src/lpcusblib
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/: ConfigDescriptor.c Host.c HostStandardReq.c Pipe.c PipeStream.c USBController.c USBMemory.c USBTask.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/EHCI/: EHCI.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/: HCD.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Class/Host/: MassStorageClassHost.c
