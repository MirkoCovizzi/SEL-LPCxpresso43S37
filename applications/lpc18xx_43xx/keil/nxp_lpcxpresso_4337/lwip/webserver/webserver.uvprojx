# Keil uVision project webserver.uvprojx, settings and files
target iflash_nxp_lpcxpresso_4337 (ARM-ADS)
  device: LPC4337:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.6.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sa_webserver
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpcxpresso_4337;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\examples\lwip\webserver\configs;..\..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\..\software\filesystems\fatfslpc
  asm define: CORE_M4
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../startup_code/: sysinit.c
    ../../../../examples/lwip/startup_code/: keil_startup_lpc18xx43xx.s
    ../../../../examples/lwip/webserver/: httpd.c webserver.c lwip_fs.c readme.txt
  group lwip
    ../../../../../../software/lwip/lpclwip/arch/: lpc18xx_43xx_systick_arch.c lpc18xx_43xx_emac.c lpc_debug.c
    ../../../../../../software/lwip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../software/lwip/lwip/src/netif/: ethernetif.c etharp.c
  group fatfs
    ../../../../../../software/filesystems/fatfslpc/: fs_mci.c rtc.c
    ../../../../../../software/filesystems/fatfs/src/: ff.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m4/: lib_lpc_chip_43xx.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/keil_output/core_m4/: lib_lpc_board_nxp_lpcxpresso_4337.lib
