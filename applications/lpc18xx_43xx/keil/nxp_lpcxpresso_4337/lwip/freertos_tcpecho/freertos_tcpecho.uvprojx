# Keil uVision project freertos_tcpecho.uvprojx, settings and files
target spifi_nxp_lpcxpresso_4337 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC4337:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.6.0
  cpu: IRAM(0x10000000,0x20000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: freertos_tcpecho
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M4
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpcxpresso_4337;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\examples\lwip\freertos_tcpecho\configs;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM4F;..\..\..\..\..\..\software\lwip\contrib\apps\tcpecho
  asm define: CORE_M4
  memory RVCT4: ROM 0x14000000 size 0x400000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../startup_code/: sysinit.c
    ../../../../examples/lwip/startup_code/: keil_startup_lpc18xx43xx.s
    ../../../../examples/lwip/freertos_tcpecho/: freertos_tcpecho.c
    ../../../../../../software/lwip/contrib/apps/tcpecho/: tcpecho.c
  group lwip
    ../../../../../../software/lwip/lpclwip/arch/: lpc18xx_43xx_emac.c lpc_debug.c sys_arch_freertos.c
    ../../../../../../software/lwip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../software/lwip/lwip/src/netif/: ethernetif.c etharp.c
  group freertos
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../../../../software/freertos/freertoslpc/: FreeRTOSCommonHooks.c
    ../../../../examples/lwip/freertos_tcpecho/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m4/: lib_lpc_chip_43xx.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/keil_output/core_m4/: lib_lpc_board_nxp_lpcxpresso_4337.lib
