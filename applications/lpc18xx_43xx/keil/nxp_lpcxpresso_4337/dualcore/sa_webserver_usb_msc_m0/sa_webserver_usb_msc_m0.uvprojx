# Keil uVision project sa_webserver_usb_msc_m0.uvprojx, settings and files
target spifi_ngx_xplorer_4330 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC4330:Cortex-M0 NXP
  pack: Keil.LPC4300_DFP.2.6.0
  cpu: IRAM(0x10000000,0x20000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: sa_webserver_usbdev_m0
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0 EXAMPLE_USB_DEVICE EXAMPLE_LWIP
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx_m0app;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\ngx_xplorer_4330;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\examples\dualcore\common;..\..\..\..\examples\dualcore\lwip\webserver\configs;..\..\..\..\..\..\software\lwip\lwip\src\include;..\..\..\..\..\..\software\lwip\lpclwip;..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4;..\..\..\..\..\..\software\filesystems\fatfs\src;..\..\..\..\..\..\software\filesystems\fatfslpc;..\..\..\..\examples\dualcore\usbd_rom\msc_ram\configs;..\..\..\..\..\..\software\lpc_core\lpc_chip\usbd_rom
  asm define: CORE_M0
  memory RVCT4: ROM 0x1a000000 size 0x10000
  memory RVCT5: ROM 0x1b000000 size 0x10000
  memory RVCT9: RAM 0x10000000 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group src
    ../../../../startup_code/: sysinit.c
    ../../../../examples/dualcore/Blinky/: dualcore_blinky.c
    ../../../../examples/dualcore/common/: ipc_example.c ipc_msg.c m0_img_ldr.c main.c
    ../../../../examples/dualcore/lwip/webserver/: dualcore_webserver.c httpd.c lwip_fs.c
    ../../../../examples/dualcore/common/startup_code/: keil_startup_lpc43xx_m0.S
    ../../../../examples/dualcore/usbd_rom/msc_ram/: msc_desc.c msc_main.c msc_ram.c ramdisk.c
  group lwip
    ../../../../../../software/lwip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../software/lwip/lwip/src/netif/: etharp.c ethernetif.c
    ../../../../../../software/lwip/lpclwip/arch/: lpc18xx_43xx_emac.c lpc18xx_43xx_systick_arch.c lpc_debug.c
  group fatfs
    ../../../../../../software/filesystems/fatfslpc/: fs_mem.c rtc.c
    ../../../../../../software/filesystems/fatfs/src/: ff.c
    ../../../../examples/dualcore/Blinky/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m0/: lib_lpc_chip_43xx_m0.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/ngx_xplorer_4330/keil_output/core_m0/: lib_lpc_board_ngx_xplorer_4330_m0.lib
software components: CMSIS:CORE 4.3.0
