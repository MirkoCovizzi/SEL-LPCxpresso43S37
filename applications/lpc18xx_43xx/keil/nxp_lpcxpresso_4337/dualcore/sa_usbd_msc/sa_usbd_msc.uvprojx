# Keil uVision project sa_usbd_msc.uvprojx, settings and files
target iflash_nxp_lpcxpresso_4337 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC4337:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.6.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sa_usbd_msc
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M4 EXAMPLE_USB_DEVICE
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpcxpresso_4337;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\examples\dualcore\common;..\..\..\..\..\..\software\lpc_core\lpc_chip\usbd_rom;..\..\..\..\examples\dualcore\usbd_rom\msc_ram\configs;..\..\..\..\..\..\software\CMSIS\CMSIS\Include
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../startup_code/: sysinit.c
    ../../../../examples/dualcore/common/: ipc_example.c ipc_msg.c m0_img_ldr.c main.c
    ../../../../examples/dualcore/common/startup_code/: keil_startup_lpc43xx_m4.S
    ../../../../examples/dualcore/blinky/: dualcore_blinky.c
    ../../../../examples/dualcore/usbd_rom/msc_ram/: msc_desc.c msc_main.c msc_ram.c ramdisk.c readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/keil_output/core_m4/: lib_lpc_board_nxp_lpcxpresso_4337.lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m4/: lib_lpc_chip_43xx.lib
