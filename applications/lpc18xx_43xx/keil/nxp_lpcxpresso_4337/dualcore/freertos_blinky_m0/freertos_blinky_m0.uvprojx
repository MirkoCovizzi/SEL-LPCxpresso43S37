# Keil uVision project freertos_blinky_m0.uvprojx, settings and files
target iflash_nxp_lpcxpresso_4337_m0 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: LPC4337:Cortex-M0 NXP
  pack: Keil.LPC4300_DFP.2.6.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: sa_blinky_m0
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0 OS_FREE_RTOS
  c include: ..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpcxpresso_4337;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx_m0app;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\examples\dualcore\common;..\..\..\..\..\..\software\freertos\freertos\Source\include;..\..\..\..\..\..\software\freertos\freertos\Source\portable\RVDS\ARM_CM0
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../examples/dualcore/common/: ipc_example.c ipc_msg.c m0_img_ldr.c main.c
    ../../../../examples/dualcore/common/startup_code/: keil_startup_lpc43xx_m0.S
    ../../../../examples/dualcore/blinky/: dualcore_blinky.c readme.txt
  group freertos
    ../../../../../../software/freertos/freertoslpc/: FreeRTOS_lpc43xx_m0_Tick.c FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/portable/RVDS/ARM_CM0/: port.c
    ../../../../examples/dualcore/common/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m0/: lib_lpc_chip_43xx_m0.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/keil_output/core_m0/: lib_lpc_board_nxp_lpcxpresso_4337_m0.lib
software components: CMSIS:CORE 4.3.0
