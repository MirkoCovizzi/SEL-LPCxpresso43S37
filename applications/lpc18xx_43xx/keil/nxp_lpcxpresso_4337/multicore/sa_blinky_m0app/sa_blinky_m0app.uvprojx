# Keil uVision project sa_blinky_m0app.uvprojx, settings and files
target iflash_nxp_lpcxpresso_4337 (ARM-ADS)
  device: LPC4337:Cortex-M0 NXP
  pack: Keil.LPC4300_DFP.2.8.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: sa_blinky_m0app
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx_m0app;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpcxpresso_4337;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\examples\multicore\common;..\..\..\..\examples\multicore\sa_blinky_m0
  memory RVCT4: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10080000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../examples/multicore/common/: ipc_example.c ipc_msg.c readme.txt
    ../../../../startup_code/: sysinit.c keil_startup_lpc43xx_m0app.s
    ../../../../examples/multicore/sa_blinky_m0/: blinky_m0.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m0/: lib_lpc_chip_43xx_m0.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/keil_output/core_m0/: lib_lpc_board_nxp_lpcxpresso_4337_m0.lib
