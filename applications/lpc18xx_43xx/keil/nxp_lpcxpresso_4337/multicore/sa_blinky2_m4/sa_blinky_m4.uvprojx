# Keil uVision project sa_blinky_m4.uvprojx, settings and files
target iflash_hitex_eva_4357 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC4337:Cortex-M4 NXP
  pack: Keil.LPC4300_DFP.2.8.0
  cpu: IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: sa_blinky_m4
  AfterMake: $K\ARM\BIN\ELFDWT.EXE !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: CORE_M4
  c include: ..\..\..\..\..\..\software\CMSIS\CMSIS\Include;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\..\..\..\..\software\lpc_core\lpc_chip\chip_common;..\..\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpcxpresso_4337;..\..\..\..\..\..\software\lpc_core\lpc_board\board_common;..\..\..\..\examples\multicore\common;..\..\..\..\examples\multicore\sa_blinky_m4
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ../../../../examples/multicore/common/: ipc_example.c ipc_msg.c m0_img_ldr.c readme.txt
    ../../../../examples/multicore/sa_blinky_m4/: blinky_m4.c
    ../../../../startup_code/: keil_startup_lpc18xx43xx.s sysinit.c
  group lib
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m4/: lib_lpc_chip_43xx.lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/keil_output/core_m4/: lib_lpc_board_nxp_lpcxpresso_4337.lib
