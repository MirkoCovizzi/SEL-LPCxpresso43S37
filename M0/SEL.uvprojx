# Keil uVision project SEL.uvprojx, settings and files
target M0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC43S37:Cortex-M0 NXP
  pack: Keil.LPC4300_DFP.2.8.0
  cpu: IRAM(0x10000000,0x08000) IRAM2(0x20000000,0x10000) IROM(0x1A000000,0x80000) IROM2(0x1B000000,0x80000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: SEL
  AfterMake: $K/ARM/BIN/ElfDwT.exe !L BASEADDRESS(0x1A000000)
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_M0
  c include: ..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\config_43xx_m0app;..\..\software\lpc_core\lpc_chip\chip_18xx_43xx;..\..\software\lpc_core\lpc_chip\chip_common;..\..\software\lpc_core\lpc_board\boards_43xx\nxp_lpcxpresso_4337;..\..\software\lpc_core\lpc_board\board_common;..\..\software\CMSIS\CMSIS\Include;..\..\applications\lpc18xx_43xx\examples\dualcore\common
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group src
    ./: main.c
  group lib
    ../../software/lpc_core/lpc_board/boards_43xx/nxp_lpcxpresso_4337/keil_output/core_m0/: lib_lpc_board_nxp_lpcxpresso_4337_m0.lib
    ../../software/lpc_core/lpc_chip/chip_18xx_43xx/keil_output/core_m0/: lib_lpc_chip_43xx_m0.lib
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0
